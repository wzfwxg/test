# Keil uVision project FunTestMDK.uvproj, settings and files
target SramEx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FunTestMDK +hex
  AfterMake: .\DownFile.exe obj\FunTestMDK.axf 范本例程.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: MDK
  c include: ..\Include;..\Source;.\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group RVMDK
    ./Source/: Application.c ApplyCfg.c ApplyCommon.c ApplyExpression.c ApplyGlobal.c ApplyMasterCom.c TxRxTask.c
    ./source/: ApplyLoraTest.c
  group Lib
    ./Include/: FunTestMDK.lib
target FlashEx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: FunTestMDK +hex
  AfterMake: .\DownFile.exe obj\FunTestMDK.axf Lora.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Include;.\Include;..\Source;.\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
